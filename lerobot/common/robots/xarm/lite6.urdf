Commit message: add homing

File: lerobot/common/robots/xarm/lite6.urdf (robot description, URDF)
Before this commit: robot lite6, 7 links, 6 joints
Links:
- added link link_tool
Joints:
- added joint joint_tool: type fixed, parent link6, child link_tool, origin xyz=0 0 0.14 rpy=0 0 0
